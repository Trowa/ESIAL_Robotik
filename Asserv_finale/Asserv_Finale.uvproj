# Keil uVision project Asserv_Finale.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Asserv_finale
  AfterMake: fromelf --bin -o @L.bin !L
  c flags: Optim=3
  c define: TARGET_LPC1768
  c include: .\mbed;.\mbed\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\mbed\LPC1768\LPC1768.sct
  link misc: .\mbed\LPC1768\startup_LPC17xx.o
.\mbed\LPC1768\system_LPC17xx.o
.\mbed\LPC1768\stackheap.o
.\mbed\LPC1768\core_cm3.o
.\mbed\LPC1768\cmsis_nvic.o
.\mbed\LPC1768\capi.ar
.\mbed\LPC1768\mbed.ar
.\mbed\LPC1768\EthernetNetIf.ar
  group src
    ./asserv/filtres/: Filtre.h
    ./asserv/odometrie/: Odometrie.h Odometrie.cpp
    ./asserv/filtres/Pid/: Pid.h Pid.cpp
    ./asserv/Utils/: Utils.h Utils.cpp
    ./asserv/: config.h
    ./asserv/filtres/QuadRampDerivee/: QuadRampDerivee.h QuadRampDerivee.cpp
    ./asserv/regulateur/: Regulateur.h Regulateur.cpp
    ./asserv/motorsController/: MotorsController.h
    ./asserv/motorsController/Md22/: Md22_config.h Md22.cpp Md22.h
    ./asserv/consignController/: ConsignController.h ConsignController.cpp
    ./asserv/commandManager/: CommandManager.cpp CommandManager.h
    ./asserv/commandManager/CMDList/: CMDList.h CMDList.cpp
    ./asserv/codeurs/: Codeur.h Codeur.cpp
    ./asserv/main/: Main.cpp Main.h
    ./asserv/debug/: DebugUDP.cpp DebugUDP.h
    ./asserv/motorsController/Qik/: Qik.cpp Qik.h Qik_config.h
target mbed NXP LPC2368 (ARM-ADS)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  AfterMake: fromelf --bin -o @L.bin  !L
  c flags: Optim=3
  c define: TARGET_LPC2368
  c include: .\mbed;.\mbed\LPC2368
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\mbed\LPC2368\LPC2368.sct
  link misc: .\mbed\LPC2368\vector_realmonitor.o
.\mbed\LPC2368\vector_functions.o
.\mbed\LPC2368\system_LPC23xx.o
.\mbed\LPC2368\stackheap.o
.\mbed\LPC2368\mbed.ar
.\mbed\LPC2368\core_arm7.o
.\mbed\LPC2368\cmsis_nvic.o
.\mbed\LPC2368\capi.ar
.\mbed\LPC2368\vector_table.o
